# Keil uVision project wpt_v2.uvprojx, settings and files
target wpt_v2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: wpt_v2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8
  c include: ../Core/Inc;C:/Users/DxjCQ/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/STM32F3xx_HAL_Driver/Inc;C:/Users/DxjCQ/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;C:/Users/DxjCQ/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/CMSIS/Device/ST/STM32F3xx/Include;C:/Users/DxjCQ/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  scatter file: stm32f334xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../Core/Src/: fz_hbridge.c main.c gpio.c tim.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    C:/Users/DxjCQ/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.3.0
